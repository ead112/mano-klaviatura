## boards/shields/custom_board/Kconfig.defconfig
```kconfig
if SHIELD_CUSTOM_BOARD

config ZMK_KEYBOARD_NAME
    default "Pro Micro NRF52840"

endif
```
